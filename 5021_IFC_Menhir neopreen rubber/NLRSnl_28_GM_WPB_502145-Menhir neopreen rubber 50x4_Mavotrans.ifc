Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T11:27:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 11:27:56 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{FE373A52-7758-40FA-902B-541CC1B7758D}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 11:27:55 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 11:27:56 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 11:27:56 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\7. Oplegmaterialen\50-Oplegmaterialen constructief; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\7. Oplegmaterialen\50-Oplegmaterialen constructief; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: NLRSnl_28_GM_WPB_5022-Menhir EPDM rubber_Mavotrans_R19:502245_50x4, 502245
In: Level 0
Type - Material: EPDM
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Breedte | Width (mm): 50 mm; Hoogte | Height (mm): 4 mm
Type - Fire Protection - Brandklasse | Fire classification: Niet getest | Not rated
Type - Forces - Belasting | Max. load: Raadpleeg het productblad | Consult the product sheet; Hardheid (shore A) | Hardness (shore A): 70° (± 5°); Maximale drukspanning bruikbaarheidsgrenstoestand | Maximum compressive stress: 5,0 N/mm²; Rek bij breuk | Elongation at break: 350%; Treksterkte | Tensile strength: 3 N/mm²
Type - General - Rol lengte | Roll length: 10 m; Verwerkingstemperatuur | Operating temperature: -40°C to 135°C
Type - Identity Data - Artikelnummer | Article number: 502245; Beschrijving | Description: Menhir EPDM rubber 50x4 mm; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; Opmerkingen | Comments: Resistent tegen chemicaliën, UV-straling en weersinvloeden | Resistant to chemicals, UV radiation and weather influences' Resistent tegen chemicaliën, UV-straling en weersinvloeden Resistent tegen chemicaliën, UV-straling en weersinvloeden; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gelinkte URL | Please refer to linked URL; Tekenaar | Draftsman: D. Blokland; Type Name: 502245_50x4; URL: https://mavotrans.nl/producten/menhir-epdm-rubber.html; Verpakkingshoeveelheid | Sales packaging: Rol van 10 m | Roll of 10 m; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Hoogwaardig mengsel van polychloropreen | High-grade mixture of polychloroprene
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_WPB_5022-Menhir EPDM rubber_Mavotrans_R19
Type - Pset_ProductRequirements - Category: Generic Models
Description: Menhir EPDM rubber 50x4 mm; Classification: 28 (Default Classification)
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_WPB_5022-Menhir EPDM rubber_Mavotrans_R19:502245_50x4; sets with these values: 2
Pset_ProvisionForVoid - Width: 4 mm; Height: 1000 mm; Depth: 4 mm
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0542 m2; Lengte | Length (mm): 1000 mm; Volume: 0.0002 m3
Other - Family: NLRSnl_28_GM_WPB_5022-Menhir EPDM rubber_Mavotrans_R19: 502245_50x4; Family and Type: NLRSnl_28_GM_WPB_5022-Menhir EPDM rubber_Mavotrans_R19: 502245_50x4; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_WPB_5022-Menhir EPDM rubber_Mavotrans_R19: 502245_50x4; Type Id: NLRSnl_28_GM_WPB_5022-Menhir EPDM rubber_Mavotrans_R19: 502245_50x4
Phasing - Phase Created: New Construction
